Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: Kryss 40 lang med sokkel speilvendt.IFC
Time: 2023-09-12T08:54:31
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Mirror1[10]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Mirror1[11]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Mirror1[12]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Mirror1[1]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Mirror1[2]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Mirror1[3]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Mirror1[4]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Mirror1[5]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Mirror1[6]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Mirror1[7]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Mirror1[8]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Mirror1[9]
In: Default Storey
PredefinedType: ELEMENT
