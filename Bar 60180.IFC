Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: Bar 60180.IFC
Time: 2019-06-07T09:21:40
Written by: SwIFC
Made in: SolidWorks 2018

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Bar 60180
In: Default Storey
PredefinedType: ELEMENT
