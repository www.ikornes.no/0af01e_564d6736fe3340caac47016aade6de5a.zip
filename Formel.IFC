Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: Formel speilvendt rotert.IFC
Time: 2019-06-06T08:51:11
Written by: SwIFC
Made in: SolidWorks 2018

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Formel for illustrasjoner speilvendt
In: Default Storey
PredefinedType: ELEMENT
