Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: Formel med sokkel.IFC
Time: 2023-09-12T09:10:42
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Boss-Extrude7[1]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Boss-Extrude7[2]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Boss-Extrude7[3]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Boss-Extrude7[4]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Boss-Extrude7[5]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Boss-Extrude7[6]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Combine1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Combine3
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude3[1]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude3[2]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude3[3]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude3[4]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude3[5]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude3[6]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude4
In: Default Storey
PredefinedType: ELEMENT
