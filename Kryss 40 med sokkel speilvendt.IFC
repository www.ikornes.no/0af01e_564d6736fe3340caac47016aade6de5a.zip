Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: Kryss 40 med sokkel speilvendt.IFC
Time: 2023-09-12T08:43:10
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Boss-Extrude3[1]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Boss-Extrude3[2]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Boss-Extrude3[3]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Boss-Extrude3[4]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude3[1]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude3[2]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude3[3]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude3[4]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Mirror1[1]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Mirror1[2]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Mirror1[7]
In: Default Storey
PredefinedType: ELEMENT
