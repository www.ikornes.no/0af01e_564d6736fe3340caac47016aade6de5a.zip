Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: Orbit 100 med bein.IFC
Time: 2019-06-06T14:32:46
Written by: SwIFC
Made in: SolidWorks 2018

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Orbit 100 med bein
In: Default Storey
PredefinedType: ELEMENT
