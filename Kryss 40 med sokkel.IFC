Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: Kryss 40 med sokkel.IFC
Time: 2023-09-12T08:32:16
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Combine2
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude4
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Mirror2[1]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Mirror2[2]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Mirror2[3]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Mirror2[4]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Mirror2[5]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Mirror2[6]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Mirror2[7]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Mirror2[8]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Split3[2]
In: Default Storey
PredefinedType: ELEMENT
