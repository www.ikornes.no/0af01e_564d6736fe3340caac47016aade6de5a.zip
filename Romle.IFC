Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: Romle.IFC
Time: 2023-09-12T09:32:31
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Boss-Extrude3 (4)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Boss-Extrude4 (4)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Combine2
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude4 (4)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Fillet15
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Split4[2]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Thicken1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Thicken2
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Thicken3
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Thicken4
In: Default Storey
PredefinedType: ELEMENT
