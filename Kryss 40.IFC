Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: Kryss 40.IFC
Time: 2020-01-21T13:06:26
Written by: SwIFC
Made in: SolidWorks 2018

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Kryss 40 en del
In: Default Storey
PredefinedType: ELEMENT
