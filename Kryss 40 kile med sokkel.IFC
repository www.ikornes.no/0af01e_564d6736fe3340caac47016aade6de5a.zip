Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: Kryss 40 kile med sokkel.IFC
Time: 2023-09-12T08:57:01
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Boss-Extrude2
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Fillet2
In: Default Storey
PredefinedType: ELEMENT
