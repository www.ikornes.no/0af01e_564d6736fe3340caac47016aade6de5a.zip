Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: Kryss 40 lang med sokkel.IFC
Time: 2023-09-12T08:52:27
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Boss-Extrude2[1]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Boss-Extrude2[2]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Boss-Extrude2[3]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Boss-Extrude2[4]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Boss-Extrude2[5]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Boss-Extrude2[6]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Boss-Extrude4[1]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Boss-Extrude4[2]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Boss-Extrude4[3]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Boss-Extrude4[4]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude3[1]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude3[2]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude3[3]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude3[4]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Split1[1]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Split2[1]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Split2[2]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Split2[3]
In: Default Storey
PredefinedType: ELEMENT
